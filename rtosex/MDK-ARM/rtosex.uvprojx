# Keil uVision project rtosex.uvprojx, settings and files
target rtosex (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtosex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;    ../Drivers/CMSIS/Include;    ..\rtos\Source\include;    ..\rtos\Source\portable\RVDS\ARM_CM3;    ..\Core\CLI\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: mythread.c main.c gpio.c dma.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c mymsgqueue.c
  group Application/User/CLI
    ../Core/CLI/: FreeRTOS_CLI.c Sample-CLI-commands.c serial.c UARTCommandConsole.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/Source
    ../rtos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Source/port
    ../rtos/Source/portable/RVDS/ARM_CM3/: port.c
    ../rtos/Source/portable/MemMang/: heap_4.c
  group FreeRTOS/RTOSconfig
    ../Core/Inc/: FreeRTOSConfig.h
software components: CMSIS:CORE 4.3.0
